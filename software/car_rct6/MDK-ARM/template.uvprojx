# Keil uVision project template.uvprojx, settings and files
target template (6220000::V6.22::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User;../User/LED;../User/APP;../User/PWM;../User/KEY;../User/USART;../User/OLED;../User/YunTai;../User/Buzzer;../User/Encoder;../User/MOTOR;../User/Eight;../User/PID;..\User\MPU6050_DMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group USER
    ../User/APP/: app.c
    ../User/LED/: led.c
    ../User/PWM/: pwm.c
    ../User/KEY/: key.c
    ../User/USART/: uart_1.c uart_2.c uart_it_config.c uart_4.c
    ../User/OLED/: oled.c
    ../User/YunTai/: yuntai.c
    ../User/Buzzer/: Buzzer.c
    ../User/MOTOR/: motor.c
    ../User/Encoder/: encoder.c
    ../User/Eight/: eight.c
    ../User/PID/: pid.c
    ../User/MPU6050_DMP/: IIC.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
software components: CMSIS:CORE 6.1.0
